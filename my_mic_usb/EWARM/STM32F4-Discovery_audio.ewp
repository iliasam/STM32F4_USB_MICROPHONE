# IAR project STM32F4-Discovery_audio.ewp, settings and files
configuration Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; STM32F407VG; USE_USB_OTG_FS; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\Libraries\STM32_USB_Device_Library\Class\audio\inc; ..\..\Libraries\STM32_USB_Device_Library\Core\inc; ..\..\Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4-Discovery_audio.hex
  ILINK.IlinkOutputFile: STM32F4-Discovery_Demo.out
  ILINK.IlinkIcfFile: stm32f40x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32_USB_Device_Library/Class/Audio
    ../../Libraries/STM32_USB_Device_Library/Class/audio/src/: usbd_audio_core.c
  group STM32_USB_Device_Library/Core
    ../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32_USB_OTG_Driver
    ../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group STM32F4_Discovery
    ../../Utilities/STM32F4-Discovery/: libPDMFilter_IAR.a pdm_filter.h stm32f4_discovery.c stm32f4_discovery_audio_codec.c stm32f4_discovery_audio_codec.h
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ../: main.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usb_conf.h usbd_conf.h usbd_desc.c usbd_usr.c waverecorder.c waverecorder.h
